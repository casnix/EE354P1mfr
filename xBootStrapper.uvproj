# Keil uVision project xBootStrapper.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51CC03 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(33000000) MODP2
  output: xBootStrapper +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BootLoader.asm HALStrapper.asm HILStrapper.asm kmain.c kthreads.c Registers.c
    ./include/asm/: ADC.inc InterruptController.inc Registers.inc ShortStack.inc MacroLang.inc
    ./include/c/: Registers.h
